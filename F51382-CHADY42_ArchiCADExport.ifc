Properties of the parts of a building model (IFC2X3)

# File
Description: ViewDefinition [CoordinationView]
Time: 2021-12-01T11:47:58
Written by: The EXPRESS Data Manager Version 5.02.0100.07 : 28 Aug 2013
Made in: 20190808_0900(x64) - Exporter 19.2.20.24 - Default UI
Comment: STEP Physical File produced by: The EXPRESS Data Manager Version 5.02.0100.07 : 28 Aug 2013 * Module: EDMstepFileFactory/EDMstandAlone * Creation date: Wed Dec 01 11:47:58 2021 * Host: ws-115 * Database: C:\Users\JACK~1.YEL\AppData\Local\Temp\{FD7A4A94-4DE6-4531-91D9-89C09F9A1807}\ifc * Database version: 5507 * Database creation date: Wed Dec 01 11:47:57 2021 * Schema: IFC2X3 * Model: DataRepository.ifc * Model creation date: Wed Dec 01 11:47:58 2021 * Header model: DataRepository.ifc_HeaderModel * Header model creation date: Wed Dec 01 11:47:58 2021 * EDMuser: sdai-user * EDMgroup: sdai-group * License ID and type: 5605 : Permanent license. Expiry date: * EDMstepFileFactory options: 020000

# IfcSite, Default
RefLatitude: 42, 24, 53, 508911; RefLongitude: -71, -15, -29, -58837; RefElevation: 0 mm
Other - Category: Project Information

# IfcBuilding
Pset_BuildingCommon - NumberOfStoreys: 1
Other - Category: Project Information

# IfcBuildingStorey, Level 1
LongName: Level 1; Elevation: 0 mm
Other(Type) - Category: Levels; Family Name: Level
Constraints - Elevation: 0 mm
Dimensions - Computation Height: 0 mm
Identity Data - Building Story: yes; Name: Level 1; Structural: no
Other - Category: Levels; Family: Level: Level 1; Family and Type: Level: Level 1; Type: Level: Level 1; Type Id: Level: Level 1
Constraints(Type) - Elevation Base: Project Base Point
Graphics(Type) - Color: 0; Line Pattern: Solid; Line Weight: 1; Symbol at End 1 Default: no; Symbol at End 2 Default: yes
Identity Data(Type) - Type Name: Level 1

# IfcFlowTerminal: Acacia E Soap Dish, AmericanStandard_SoapDish_AcaciaE_(F51382-CHADY42):Acacia E Soap Dish:3390
In: Level 1
Classification: C1030200 (Uniformat); Material: Glass - Frosted, Chrome
Pset_ManufacturerTypeInformation - ModelReference: Acacia E Soap Dish; Manufacturer: American Standard; ProductionYear: 2021
Pset_DistributionFlowElementCommon - Reference: Acacia E Soap Dish
Constraints - Elevation: 0 mm
Dimensions - Area: 0.0262803 m2; Volume: 0.000150071 m3
Other - AssetIdentifier: n/a; BarCode: Please Record On Commissioning.; Category: Generic Models; Family: AmericanStandard_SoapDish_AcaciaE_(F51382-CHADY42): Acacia E Soap Dish; Family and Type: AmericanStandard_SoapDish_AcaciaE_(F51382-CHADY42): Acacia E Soap Dish; InstallationDate: Please Record On Commissioning.; SerialNumber: Please Record On Commissioning.; Type: AmericanStandard_SoapDish_AcaciaE_(F51382-CHADY42): Acacia E Soap Dish; Type Id: AmericanStandard_SoapDish_AcaciaE_(F51382-CHADY42): Acacia E Soap Dish; WarrantyStartDate: Please Record On Commissioning.
Phasing - Phase Created: New Construction
Constraints(Type) - Default Elevation: 850 mm
Data(Type) - ConnectionSize: n/a; FlowRate: n/a; InstallationType: n/a; ProductCategory: n/a; ProductGroup: n/a; ProductWeight: n/a; StyleSegment: n/a; SubCategory: n/a
Identity Data(Type) - Assembly Code: C1030200; Description: Acacia E Soap Dish; Keynote: N13; Manufacturer: American Standard; Model: Acacia E Soap Dish; OmniClass Number: 23.40.20.21.21; OmniClass Title: Toilet Paper Dispensers; Type Comments: F51382-CHADY42; Type Name: Acacia E Soap Dish; URL: https://www.americanstandard-apac.com/
Model Properties(Type) - _Author: bimstore; _AuthorizedBy: bimstore; _BimSpecGuid: 0; _BSBibleVersion: 16; _CreatedBy: https://www.bimstore.co; _CurrentRevision: 1; _DistributedBy: https://www.bimstore.co; _ObjectUserGuide: https://www.bimstore.co/products/f51382-chady42/document/object-user-guide; BIMObjectName: AmericanStandard_SoapDish_AcaciaE_(F51382-CHADY42); NBSDescription: Soap dishes; NBSNote: n/a; NBSObjectName: American Standard - Soap dishes; NBSOfficeMasterTag: n/a; NBSReference: 45-35-72/356
Other(Type) - Category: Generic Models; AccessibilityPerformance: n/a; AssetType: Fixed; ClassificationName: Uniclass2015; ClassificationValue: Pr_40_20_76_82; CodePerformance: n/a; Color: n/a; Constituents: n/a; CreatedBy: https://www.americanstandard-apac.com/; CreatedOn: 2021-12-01T09:00:00; DocumentationCertificates: https://www.bimstore.co/products/f51382-chady42/document/product-certificates; DocumentationInstallationGuide: https://www.bimstore.co/products/f51382-chady42/document/installation-guide; DocumentationLiterature: https://www.bimstore.co/products/f51382-chady42/document/product-literature; DocumentationMaintenance: https://www.bimstore.co/products/f51382-chady42/document/maintenance-information; DocumentationTechnical: https://www.bimstore.co/products/f51382-chady42/document/technical-data-sheet; DurationUnit: Years; ExpectedLife: 0; Family Name: AmericanStandard_SoapDish_AcaciaE_(F51382-CHADY42); Features: n/a; Finish: n/a; Grade: n/a; ManufacturerName: American Standard; Material: n/a; ModelNumber: F51382-CHADY42; ModelReference: Acacia E Soap Dish; ProductionYear: 2021; ReferencedStandard: n/a; ReplacementCost: n/a; Shape: n/a; Size: n/a; TypeName: Acacia E Soap Dish; WarrantyDescription: n/a; WarrantyDurationLabor: 0; WarrantyDurationParts: 0; WarrantyDurationUnit: Years; WarrantyGuarantorLabor: https://www.americanstandard-apac.com/; WarrantyGuarantorParts: https://www.americanstandard-apac.com/
Plumbing(Type) - CW Connection: no; HW Connection: no; Vent Connection: no; Waste Connection: no
